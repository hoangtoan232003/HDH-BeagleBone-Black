## Autostart/Config.in
```kconfig
config BR2_PACKAGE_BEAGLEBONE
    bool "beaglebone"
    default n
    help
      App + drivers + autostart for BeagleBone Black
```
